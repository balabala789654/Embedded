# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4
  c include: ..\Driver\CORE;..\Driver\FWLIB\inc;..\HARDWARE;..\USER\SYSTEM;..\MDK;..\USER\algorithm;..\USER;..\Driver\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
    ../USER/SYSTEM/: delay.c sys.c
  group Driver
    ../Driver/CORE/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group Hardware
    ../HARDWARE/: gpio.c spi.c timer.c usart.c can.c
  group User
    ../USER/: as5047.c location_sensor.c low_pass_filter.c
  group Lib
    ../Driver/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Driver/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c arm_sqrt_q15.c
    ../Driver/CMSIS/DSP/Source/BasicMathFunctions/: arm_add_f32.c arm_mult_f32.c
    ../../sensor_test/Driver/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
