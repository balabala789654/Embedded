# Keil uVision project MASTER2021.uvprojx, settings and files
target 2021 NCIST infantry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;.\user_lib;..\Math\pid;..\Math\kalman;..\Math\Ramp;..\HARDWARE\LED;..\HARDWARE\rc;..\HARDWARE\can;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS;..\TASK\Start_Task;..\TASK\remote_control;..\TASK\CAN_receive;..\TASK\gimbal_task;..\TASK\chassis_task;..\mpu;..\mpu\TransformFunctions;..\TASK\shoot_task;..\TASK\tx2_task;..\TASK\detect_task;..\TASK\judge_task;..\HARDWARE\TIMER;..\TASK\ui_task;..\APP\chassis_app;..\APP\gimbal_app;..\HARDWARE\BEEP;..\APP\oled_app;..\HARDWARE\ADC;..\TASK\oled_task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.h main.c stm32f4xx_it.c system_stm32f4xx.c
    ../TASK/Start_Task/: start_task.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/rc/: rc.c
    ../HARDWARE/can/: can.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ADC/: adc.c
  group TASK
    ../TASK/Start_Task/: start_task.c
    ../TASK/remote_control/: remote_control.c
    ../TASK/CAN_receive/: CAN_receive.c
    ../TASK/gimbal_task/: gimbal_task.c
    ../TASK/chassis_task/: chassis_task.c
    ../TASK/shoot_task/: shoot_task.c
    ../TASK/tx2_task/: Tx2_task.c
    ../TASK/detect_task/: detect_task.c
    ../TASK/ui_task/: ui_task.c
    ../TASK/oled_task/: oled_task.c
  group JudgeTASK
    ../TASK/judge_task/: Readme.txt Judge_Task.c judgement_info.c protocol.c get_judge_measure.c RM_Cilent_UI.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart1.c usart6.c
  group MPU
    ../mpu/: accelerometer_calibration.c BSP_Flash.c BSP_MPU9250_Init.c Filter_Control.c IMUTask.c mpu_delay.c MPU_SPI_Init.c MPU_TIME_Init.c arm_cortexM4lf_math.lib
  group MATH
    ../Math/pid/: pid.c
    ../Math/kalman/: kalman.c kalman_filter.c
    ../Math/Ramp/: Ramp_Control.c
  group User_lib
    ./user_lib/: user_lib.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c cmsis_os.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group APP
    ../APP/chassis_app/: chassis_app.c
    ../APP/gimbal_app/: gimbal_app.c
    ../APP/oled_app/: OLED.c
