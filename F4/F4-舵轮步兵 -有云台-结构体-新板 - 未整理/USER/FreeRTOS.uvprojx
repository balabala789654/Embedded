# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\CAN;..\HARDWARE\PID;..\HARDWARE\remote_control;..\TASK\motor_task;..\TASK\start_task;..\TASK\start_task;..\HARDWARE\CAN2;..\HARDWARE\rc;..\USER;..\TASK\detect_task;..\TASK\chassis_task;..\mpu;..\user_lib;..\FreeRTOS;..\mpu\BasicMathFunctions;..\mpu\CommonTables;..\mpu\ComplexMathFunctions;..\mpu\ControllerFunctions;..\mpu\FastMathFunctions;..\mpu\FilteringFunctions;..\mpu\MatrixFunctions;..\mpu\StatisticsFunctions;..\mpu\SupportFunctions;..\mpu\TransformFunctions;..\TASK\gimbal_task;..\TASK\can_receive;..\Math\Ramp;..\Math\kalman;..\TASK\detect_task;..\TASK\judge_task;..\SYSTEM\usart;..\TASK\shoot_task;..\HARDWARE\timer;..\TASK\Tx2_task;..\App;..\TASK\ui_task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/remote_control/: remote_control.c
    ../HARDWARE/rc/: rc.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/timer/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart1.c usart6.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c
    ../../底盘/FWLIB/src/: stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c cmsis_os.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group TASK
    ../TASK/start_task/: start_task.c
    ../TASK/gimbal_task/: gimbal_task.c
    ../TASK/chassis_task/: chassis_task.c
    ../TASK/can_receive/: can_receive.c
    ../TASK/detect_task/: detect_task.c
    ../TASK/shoot_task/: shoot_task.c
    ../TASK/Tx2_task/: Tx2_task.c
    ../TASK/ui_task/: ui_task.c
  group user_lib
    ../user_lib/: user_lib.c
  group mpu
    ../mpu/: accelerometer_calibration.c BSP_Flash.c BSP_MPU9250_Init.c Filter_Control.c IMUTask.c mpu_delay.c MPU_SPI_Init.c MPU_TIME_Init.c arm_cortexM4lf_math.lib
  group math
    ../Math/Ramp/: Ramp_Control.c
    ../Math/kalman/: kalman.c kalman_filter.c
  group JudgeTASK
    ../TASK/judge_task/: RM_Cilent_UI.c get_judge_measure.c Judge_Task.c judgement_info.c protocol.c
  group App
    ../App/: gimbal_app.c OLED.c
software components: CMSIS:DSP 1.9.0-dev
