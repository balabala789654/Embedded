# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; PART_TM4C129XNCZAD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\net\lwip\lwip-1.4.1\src\include\ipv4; ..\..\include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; libraries\driverlib; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\ipc; drivers; .; libraries\inc; ..\..\libcpu\arm\cortex-m4; ..\..\components\libc\posix\io\eventfd; ..\..\components\net\lwip\lwip-1.4.1\src\include; ..\..\components\libc\compilers\common\include; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\net\lwip\lwip-1.4.1\src\include\netif; ..\..\components\net\lwip\port; ..\..\components\finsh; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\posix\io\epoll; libraries
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: tm4c_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; PART_TM4C129XNCZAD
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c board.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_uart.c drv_eth.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/driverlib/: watchdog.c cpu.c pwm.c des.c mpu.c sysexc.c flash.c uart.c lcd.c comp.c eeprom.c qei.c ssi.c onewire.c usb.c emac.c shamd5.c hibernate.c systick.c adc.c epi.c can.c tiva_timer.c i2c.c fpu.c sw_crc.c udma.c crc.c aes.c sysctl.c interrupt.c gpio.c
    libraries/startup/: startup_ewarm.c
  group lwIP
    ../../components/net/lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-1.4.1/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/lwip-1.4.1/src/netif/: etharp.c slipif.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
