# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: CPU_LPC55S69JBD100_cm33_core0; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_LPC55S69JBD100_cm33_core0; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: board\MCUX_Config\board; ..\..\..\components\drivers\include; ..\..\..\libcpu\arm\cortex-m33; ..\..\..\components\finsh; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\posix\ipc; ..\Libraries\LPC55S6X\LPC55S6X; .; ..\Libraries\CMSIS\Core\Include; board; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\include; ..\Libraries\drivers; ..\Libraries\LPC55S6X\LPC55S6X\drivers; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\Libraries\LPC55S6X\middleware\sdmmc\inc; ..\Libraries\LPC55S6X\middleware\sdmmc\port; ..\Libraries\LPC55S6X\components\codec; ..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../Libraries/LPC55S6X/LPC55S6X/drivers/: fsl_hashcrypt.c fsl_usart_dma.c fsl_spi_dma.c fsl_cmp.c fsl_utick.c fsl_common_arm.c fsl_power.c fsl_i2s_dma.c fsl_gpio.c fsl_casper.c fsl_clock.c fsl_reset.c fsl_sctimer.c fsl_common.c fsl_rtc.c fsl_crc.c fsl_sdif.c fsl_plu.c fsl_mrt.c fsl_i2s.c fsl_spi.c fsl_ctimer.c fsl_gint.c fsl_dma.c fsl_sysctl.c fsl_flexcomm.c fsl_pint.c fsl_powerquad_basic.c fsl_usart.c fsl_puf.c fsl_rng.c fsl_lpadc.c fsl_inputmux.c fsl_i2c_dma.c fsl_i2c.c fsl_wwdt.c fsl_anactrl.c fsl_iap.c fsl_ostimer.c
    ../Libraries/LPC55S6X/LPC55S6X/iar/: startup_LPC55S69_cm33_core0.s
    ../Libraries/LPC55S6X/LPC55S6X/: system_LPC55S69_cm33_core0.c
