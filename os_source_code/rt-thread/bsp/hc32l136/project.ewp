# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; USE_DDL_DRIVER; HC32L136; __DEBUG; __RTTHREAD__
  ICCARM.CCIncludePath2: ..\..\components\libc\posix\ipc; ..\..\components\libc\posix\io\eventfd; Libraries\CMSIS\Include; ..\..\components\libc\compilers\common\extension; ..\..\include; Libraries\CMSIS\Device\HDSC\HC32L136\Include; drivers; ..\..\components\libc\compilers\common\include; Libraries\HC32L136_StdPeriph_Driver\inc; .; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\libc\posix\io\epoll; board; ..\..\libcpu\arm\cortex-m0; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh; ..\..\components\libc\posix\io\poll
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCDefines: __DEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; USE_DDL_DRIVER; HC32L136; __DEBUG; __RTTHREAD__
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group HC32_StdPeriph
    Libraries/HC32L136_StdPeriph_Driver/src/: trim.c uart.c sysctrl.c gpio.c ddl.c timer3.c flash.c lpuart.c rtc.c adc.c
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/: system_hc32l13x.c interrupts_hc32l136.c
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/IAR/: startup_hc32l136.s
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
