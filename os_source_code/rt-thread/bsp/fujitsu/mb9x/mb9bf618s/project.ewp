# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF618S Fujitsu MB9BF618S
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MB9B610S; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\include; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\posix\io\eventfd; drivers; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\libcpu\arm\cortex-m3; ..\..\..\..\components\libc\posix\io\epoll; applications; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\libcpu\arm\common; CMSIS\Include; .; CMSIS\DeviceSupport\fujitsu\mb9bf61x; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: rtthread-fm3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MB9B610S; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: template.out
  group Applications
    applications/: startup.c application.c
  group CMSIS
    CMSIS/DeviceSupport/fujitsu/mb9bf61x/: system_mb9bf61x.c
    CMSIS/DeviceSupport/fujitsu/mb9bf61x/startup/iar/: startup_mb9bf61x.S
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: pin.c
    ../../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: board.c serial.c led.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
