# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403AVGT7 ArteryTek AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; HK32F030x8; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m0; ..\libraries\HK32F0xx_StdPeriph_Driver\inc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\include; board\msp; ..\..\..\components\libc\posix\io\epoll; ..\libraries\rt_drivers; .; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\libraries\HK32F0xx_StdPeriph_Driver\CMSIS\HK32F0xx\Include; ..\..\..\components\libc\compilers\common\include; ..\libraries\HK32F0xx_StdPeriph_Driver\CMSIS\Core; ..\..\..\include; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    board/msp/: hk32_msp.c
    ../libraries/HK32F0xx_StdPeriph_Driver/CMSIS/HK32F0xx/Source/iar/: startup_hk32f030x4x6x8.s
    ../libraries/HK32F0xx_StdPeriph_Driver/CMSIS/HK32F0xx/Source/: system_hk32f0xx.c
    ../libraries/rt_drivers/: drv_gpio.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/HK32F0xx_StdPeriph_Driver/src/: hk32f0xx_rtc.c hk32f0xx_syscfg.c hk32f0xx_exti.c hk32f0xx_wwdg.c hk32f0xx_misc.c hk32f0xx_i2c.c hk32f0xx_iwdg.c hk32f0xx_flash.c hk32f0xx_divsqrt.c hk32f0xx_gpio.c hk32f0xx_crc.c hk32f0xx_spi.c hk32f0xx_pwr.c hk32f0xx_dma.c hk32f0xx_dbgmcu.c hk32f0xx_rcc.c hk32f0xx_tim.c hk32f0xx_usart.c hk32f0xx_adc.c
