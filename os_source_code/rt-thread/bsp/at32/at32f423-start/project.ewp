# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: AT32F423VCT7_v2 ArteryTek -AT32F423VCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; AT32F423VCT7; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\io\stdio; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\ipc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; board\inc; ..\libraries\AT32F423_Firmware_Library\cmsis\cm4\device_support; ..\libraries\AT32F423_Firmware_Library\cmsis\cm4\core_support; ..\..\..\components\drivers\include; ..\libraries\AT32F423_Firmware_Library\drivers\inc; ..\libraries\rt_drivers; .; ..\libraries\usbfs_library\inc; applications; ..\libraries\rt_drivers\config; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\include; ..\..\..\include; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F423_Firmware_Library/cmsis/cm4/device_support/startup/iar/: startup_at32f423.s
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/AT32F423_Firmware_Library/drivers/src/: at32f423_flash.c at32f423_wwdt.c at32f423_spi.c at32f423_tmr.c at32f423_crm.c at32f423_scfg.c at32f423_usb.c at32f423_can.c at32f423_usart.c at32f423_crc.c at32f423_wdt.c at32f423_xmc.c at32f423_misc.c at32f423_dma.c at32f423_pwc.c at32f423_i2c.c at32f423_adc.c at32f423_acc.c at32f423_dac.c at32f423_ertc.c at32f423_exint.c at32f423_debug.c at32f423_gpio.c
    ../libraries/AT32F423_Firmware_Library/cmsis/cm4/device_support/: system_at32f423.c
