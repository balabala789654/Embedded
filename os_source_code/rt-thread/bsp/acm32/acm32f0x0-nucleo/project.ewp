# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; libraries\HAL_Driver\Inc; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\libc\posix\ipc; applications; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\include; ..\..\..\libcpu\arm\cortex-m0; libraries\Device; ..\..\..\components\finsh; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\..\..\libcpu\arm\common; .; ..\..\..\include; drivers; libraries\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: template.out
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_IWDT.c HAL_UART.c HAL_RTC.c HAL_EXTI.c HAL_DMA.c HAL_TIMER.c HAL_ADC.c HAL_I2C.c HAL_CRC.c HAL_WDT.c HAL_SPI.c HAL_GPIO.c
    libraries/Device/: Startup_ACM32F0x0_iar.s System_ACM32F0x0.c
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    drivers/: drv_soft_i2c.c drv_i2c.c drv_hwtimer.c drv_rtc.c drv_adc.c drv_spi.c drv_gpio.c drv_uart.c drv_pm.c board.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
