# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: APM32F051R8 Geehy APM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; APM32F051x8; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m0; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\libraries\Drivers; ..\libraries\Drivers\config; ..\..\..\components\drivers\include; board\ports; ..\libraries\APM32F0xx_Library\CMSIS\Include; ..\..\..\components\libc\posix\io\eventfd; .; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\include; ..\libraries\APM32F0xx_Library\APM32F0xx_StdPeriphDriver\inc; ..\..\..\include; ..\libraries\APM32F0xx_Library\Device\Geehy\APM32F0xx\Include; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    ../libraries/APM32F0xx_Library/Device/Geehy/APM32F0xx/Source/iar/: startup_apm32f051.s
    ../libraries/Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/APM32F0xx_Library/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_eint.c apm32f0xx_misc.c apm32f0xx_gpio.c apm32f0xx_usart.c apm32f0xx_syscfg.c apm32f0xx_rcm.c
    ../libraries/APM32F0xx_Library/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
