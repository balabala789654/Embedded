# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32F746xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\extension; board\CubeMX_Config\Inc; ..\libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\components\libc\posix\ipc; ..\libraries\HAL_Drivers\CMSIS\Include; .; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\drivers\spi; ..\libraries\HAL_Drivers; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\include; board\ports; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc; ..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c soft_rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_cryp.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_rtc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_spi.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_crc_ex.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
