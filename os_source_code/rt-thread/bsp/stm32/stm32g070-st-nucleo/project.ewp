# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070RB ST STM32G070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32G070xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\libraries\STM32G0xx_HAL\STM32G0xx_HAL_Driver\Inc; ..\libraries\STM32G0xx_HAL\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\components\libc\compilers\common\extension; board\CubeMX_Config\Inc; ..\..\..\components\libc\posix\ipc; ..\libraries\HAL_Drivers\CMSIS\Include; .; ..\libraries\HAL_Drivers\config; board; ..\libraries\HAL_Drivers; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\include; board\ports; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\cortex-m0; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
    ../libraries/STM32G0xx_HAL/CMSIS/Device/ST/STM32G0xx/Source/Templates/iar/: startup_stm32g070xx.s
    board/CubeMX_Config/Src/: stm32g0xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32G0xx_HAL/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_cec.c stm32g0xx_hal_pwr.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_pwr_ex.c stm32g0xx_ll_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_rcc.c stm32g0xx_hal_dma.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
    ../libraries/STM32G0xx_HAL/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
