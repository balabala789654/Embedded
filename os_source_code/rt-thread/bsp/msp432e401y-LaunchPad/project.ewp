# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __MSP432E401Y__; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\msp432e4\driverlib; ..\..\components\libc\posix\io\eventfd; ..\..\components\libc\compilers\common\extension; ..\..\include; ..\..\components\libc\posix\ipc; ..\..\components\finsh; ..\..\components\libc\compilers\common\include; libraries\msp432e4\inc; ..\..\libcpu\arm\cortex-m4; .; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\libc\posix\io\epoll; libraries\msp432e4\driverlib\inc; board; ..\..\components\drivers\include; ..\..\libcpu\arm\common; libraries\Drivers\config; libraries\Drivers\CMSIS\Include; libraries\Drivers; ..\..\components\libc\posix\io\poll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    libraries/libraries/msp432e4/startup_system_files/iar/: startup_msp432e401y_ewarm.c
    libraries/Drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/msp432e4/driverlib/: uart.c interrupt.c gpio.c sysctl.c systick.c cpu.c fpu.c
    libraries/msp432e4/startup_system_files/: system_msp432e401y.c
