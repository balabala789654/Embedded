# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; CPU_MIMXRT1176DVMAA_cm7; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; ARM_MATH_CM7; USE_SDRAM; ENDIANNESS; USE_RTOS; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\compilers\common\extension; ..\..\libraries\MIMXRT1170\MIMXRT1176; ..\..\libraries\MIMXRT1170\CMSIS\Include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\drivers\usb\usbhost\include; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\posix\io\epoll; ..\..\libraries\MIMXRT1170\MIMXRT1176\drivers\cm7; ..\..\libraries\drivers; ..\..\..\..\libcpu\arm\cortex-m7; .; xip; board; ..\..\libraries\MIMXRT1170\MIMXRT1176\drivers; ..\..\..\..\components\net\netdev\include; ..\..\..\..\components\drivers\usb\usbhost\core; ..\..\..\..\components\drivers\include; board\MCUX_Config; ..\..\..\..\components\drivers\usb\usbhost\class; board\ports; applications; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\include; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\finsh; ..\..\..\..\components\drivers\usb\usbhost
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: pin.c
    ../../../../components/drivers/phy/: phy.c
    ../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c dcd.c
    ../../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c drv_usbh.c
    ../../libraries/drivers/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    ../../libraries/drivers/usb/phy/: usb_phy.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../../libraries/MIMXRT1170/MIMXRT1176/drivers/: fsl_pmu.c fsl_lpuart.c fsl_gpio.c fsl_os_abstraction_rtthread.c fsl_anatop_ai.c fsl_dcdc.c fsl_common_arm.c fsl_common.c generic_list.c fsl_clock.c
    ../../libraries/MIMXRT1170/MIMXRT1176/: system_MIMXRT1176_cm7.c
    ../../libraries/MIMXRT1170/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
    ../../libraries/MIMXRT1170/MIMXRT1176/drivers/cm7/: fsl_cache.c
  group rt_usbh
    ../../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group xip
    xip/: fsl_flexspi_nor_boot.c evkmimxrt1170_flexspi_nor_config.c
