# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: ES32F3696LT Eastsoft ES32F3696LT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; ES32F36xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\libcpu\arm\cortex-m3; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; drivers\ES; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\epoll; libraries\ES32F36xx_ALD_StdPeriph_Driver\Include; .; applications; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\include; ..\..\..\include; drivers; libraries\CMSIS\Device\EastSoft\ES32F36xx\Include; libraries\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c signal.c thread.c timer.c
  group Libraries
    libraries/ES32F36xx_ALD_StdPeriph_Driver/Source/: ald_i2s.c ald_trng.c ald_flash.c ald_iap.c ald_crypt.c ald_timer.c ald_bkpc.c ald_rtc.c ald_wdt.c ald_can.c ald_rtchw.c ald_usb.c ald_dma.c ald_rmu.c ald_nand.c ald_tsense.c ald_dac.c ald_uart.c ald_crc.c ald_i2c.c ald_flash_ext.c ald_gpio.c ald_ebi.c ald_nor_lcd.c utils.c ald_calc.c ald_pis.c ald_qspi.c ald_adc.c ald_pmu.c ald_cmu.c ald_sram.c ald_acmp.c ald_spi.c
    libraries/CMSIS/Device/EastSoft/ES32F36xx/Startup/iar/: startup_es32f36xx.s
