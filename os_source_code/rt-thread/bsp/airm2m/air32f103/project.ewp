# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\libcpu\arm\cortex-m3; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; libraries\CMSIS\Include; board\ports; libraries\AIR32F10xLib\inc; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\epoll; .; libraries; applications; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\include; ..\..\..\include; libraries\rt_drivers; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    libraries/AIR32F10xLib/src/: air32f10x_adc.c air32f10x_bkp.c air32f10x_can.c air32f10x_crc.c air32f10x_dac.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_flash.c air32f10x_fsmc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_iwdg.c air32f10x_otp.c air32f10x_pwr.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_rtc.c air32f10x_sdio.c air32f10x_spi.c air32f10x_tim.c air32f10x_trng.c air32f10x_usart.c air32f10x_wwdg.c misc.c system_air32f10x.c
    libraries/Startup/iar/: startup_air32f10x.s
    libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
