# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\dfs\dfs_v1\include; ..\..\include; ..\..\components\libc\posix\io\eventfd; ..\..\components\net\lwip\lwip-2.0.3\src\include\posix; CMSIS\CMSIS\Include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\components\libc\posix\ipc; CMSIS\CM3\DeviceSupport\NXP\LPC17xx; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; .; ..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\components\libc\posix\io\poll; ..\..\libcpu\arm\cortex-m3; ..\..\components\dfs\dfs_v1\filesystems\elmfat; ..\..\components\libc\compilers\common\include; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\finsh; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\posix\io\epoll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: rtthread-lpc17xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: platform.c startup.c application.c
  group CMSIS
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/iar/: startup_LPC17xx.s
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: emac.c spi.c led.c sd.c uart.c board.c
  group Filesystem
    ../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group lwIP
    ../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
