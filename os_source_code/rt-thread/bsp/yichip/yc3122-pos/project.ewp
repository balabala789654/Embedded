# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: SWM320xE Synwit SWM320xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __USE_YC_M0__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; Libraries\core; ..\..\..\components\drivers\include; Libraries; ..\..\..\components\libc\compilers\common\extension; drivers\ports; ..\..\..\components\libc\posix\ipc; drivers; Libraries\CMSIS\Device\YICHIP\YC3122\Include; .; Libraries\sdk; ..\..\..\components\drivers\spi; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\include; Libraries\CMSIS\Include; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\cortex-m0; ..\..\..\libcpu\arm\common; ..\..\..\components\drivers\spi\sfud\inc; ..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    Libraries/sdk/: yc_exti.c yc_gpio.c yc_uart.c yc_wdt.c
    Libraries/core/: system.c
    Libraries/CMSIS/Device/YICHIP/YC3122/Source/Templates/iar/: startup_yc3122.s
    Libraries/CMSIS/Device/YICHIP/YC3122/Source/Templates/: system_yc3122.c
