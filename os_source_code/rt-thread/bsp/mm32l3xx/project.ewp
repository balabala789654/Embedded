# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: MM32L373PF MindMotion MM32L373PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Libraries\MM32L3xx\Source; ..\..\components\libc\posix\io\eventfd; ..\..\components\libc\posix\io\poll; ..\..\components\libc\compilers\common\extension; ..\..\include; Libraries\CMSIS\KEIL_CORE; drivers; ..\..\components\libc\compilers\common\include; ..\..\components\libc\posix\ipc; .; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\libc\posix\io\epoll; Libraries\MM32L3xx\HAL_lib\inc; ..\..\libcpu\arm\cortex-m3; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh; Libraries\MM32L3xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    Libraries/MM32L3xx/Source/IAR_StartAsm/: startup_MM32L3xx.s
    Libraries/MM32L3xx/HAL_lib/src/: HAL_dma.c HAL_uart.c HAL_crc.c HAL_exti.c HAL_rtc.c HAL_misc.c HAL_wwdg.c HAL_flash.c HAL_spi.c HAL_can.c HAL_iwdg.c HAL_tim.c HAL_pwr.c HAL_dac.c HAL_i2c.c HAL_gpio.c HAL_bkp.c HAL_rcc.c HAL_adc.c
    Libraries/MM32L3xx/Source/: system_MM32L3xx.c
