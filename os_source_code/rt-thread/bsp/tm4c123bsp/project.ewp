# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\libc\posix\ipc; ..\..\components\libc\posix\io\eventfd; libraries\TivaWare_C_series\tm4c123_driverlib; ..\..\components\libc\compilers\common\extension; ..\..\include; libraries\TivaWare_C_series\tm4c123_driverlib\driverlib; ..\..\components\libc\compilers\common\include; libraries\TivaWare_C_series\tm4c123_driverlib\driverlib\inc; ..\..\libcpu\arm\cortex-m4; ..\..\components\drivers\spi; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\libc\posix\io\epoll; board; ..\..\components\drivers\include; ..\..\libcpu\arm\common; libraries\Drivers\config; .; ..\..\components\finsh; libraries\Drivers; ..\..\components\libc\posix\io\poll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: board.c tm4c123_config.c
    libraries/TivaWare_C_series/tm4c123_driverlib/startup/iar/: startup_rvmdk.S
    libraries/Drivers/: drv_adc.c drv_gpio.c drv_pwm.c drv_spi.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/TivaWare_C_series/tm4c123_driverlib/src/: gpio.c sysctl.c pwm.c interrupt.c ssi.c adc.c fpu.c uart.c systick.c cpu.c
